options:
  parameters:
    generate_options: qt_gui
    id: pulse_shape
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '4'
    type: float
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE340/LAB6/22b3922_lab06/matched.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE340/LAB6/22b3922_lab06/Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1e-3'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0_0_1
  id: blocks_skiphead
  parameters:
    num_items: '4'
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '-0.1'
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1,1]'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: fff
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    gain: '1'
    interp: '1'
    samp_rate: '400000'
    type: interp_fir_filter_fff
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '8'
    size: '1024'
    srate: '80000'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '80000'
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: '400000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '80000'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: '10000'
    stemplot: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: '10000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '80000'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '80000'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: '80000'
    sym_rate: '10000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: '88'
    samp_rate: '80000'
    sym_rate: '10000'
    type: fir_filter_fff
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1, '1']
- [blocks_abs_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_complex_to_real_0, '0', blocks_multiply_xx_0, '0']
- [blocks_delay_0, '0', fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_skiphead_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_0_1_0_0_1_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_pack_k_bits_bb_0_0_1, '0', blocks_file_sink_0_0_1, '0']
- [blocks_skiphead_0_0_1, '0', blocks_pack_k_bits_bb_0_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', blocks_abs_xx_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_0, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_delay_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', qtgui_freq_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
