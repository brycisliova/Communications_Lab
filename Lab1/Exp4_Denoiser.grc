options:
  parameters:
    author: Jatin
    generate_options: qt_gui
    id: Exp4_Denoiser
    output_language: python
    title: Exp4_Denoiser
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '42000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE341/22B3922_Lab01/shor.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
