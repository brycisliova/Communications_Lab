options:
  parameters:
    author: Jatin
    generate_options: qt_gui
    id: Exp2_MusicSynthesis
    output_language: python
    title: Exp2_MusicSynthesis
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE341/22B3922_Lab01/background.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/jatin/Desktop/IITB_Files/EE341/22B3922_Lab01/vocal.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '441'
    interp: '441'
    type: fff
  states: {}

connections:
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_1, '0', blocks_add_xx_0, '1']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
